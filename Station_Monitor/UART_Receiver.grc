options:
  parameters:
    generate_options: qt_gui
    id: UART_Receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '64'
  states: {}
- name: lp_cutoff_freq
  id: variable_qtgui_range
  parameters:
    label: Low-Pass Frequency
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 500e3
    value: 100e3
  states: {state: disabled}
- name: lp_cutoff_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: lp_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: lp_trans_width
  id: variable_qtgui_range
  parameters:
    label: Low-Pass Transition Width
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 50e3
    value: 10e3
  states: {state: disabled}
- name: lp_trans_width
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: xlate_freq
  id: variable_qtgui_range
  parameters:
    label: Xlate Frequency
    orient: Qt.Horizontal
    start: '-200e3'
    step: 1e3
    stop: 200e3
    value: '-55e3'
  states: {state: disabled}
- name: xlate_freq
  id: variable
  parameters:
    value: '-55e3'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: 434e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/bodokaiser/Repositories/github.com/bodokaiser/arduino-rtlsdr/data/output.bin
    type: float
  states: {state: disabled}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_freq
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cutoff_freq
    decim: decimation
    gain: lp_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: lp_trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate / decimation
    color1: '"dark green"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: Raw
    legend: 'False'
    name: Xlated, Filtered and Decimated
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: Raw
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Raw
    name: Analog
    size: '1024'
    srate: samp_rate / decimation
    type: float
    ylabel: Magnitude
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Digital
    size: '1024'
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:3000
    timeout: '100'
    type: int
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_max_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_int_0, '0', zeromq_pub_sink_0, '0']
- [blocks_max_xx_0, '0', blocks_float_to_int_0, '0']
- [blocks_max_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_max_xx_0, '1']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
