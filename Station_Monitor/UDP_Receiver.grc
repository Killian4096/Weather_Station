options:
  parameters:
    generate_options: qt_gui
    id: UDP_Receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '50002'
    psize: '1024'
    type: float
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
